# Autodesk Inventor part: magnet
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2021-10
Part Number: magnet
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: magnet v3
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
